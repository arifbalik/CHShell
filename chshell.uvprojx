# Keil uVision project chshell.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: chshell
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: getline.c getopt.c getopt1.c main.c stdin_keyboard.c stdout_display.c chshell_core.c
  group CH_Modules
    ./: chshell_gpio.c chshell_system.c chshell_adc.c
software components: CMSIS:CORE 4.3.0, CMSIS:RTOS:Keil RTX 4.80.0, USB:CORE 6.5.0, USB:Host 6.5.0, USB:Host:HID 6.5.0, Board Support:Drivers:SDRAM 1.0.0, Board Support:Graphic LCD 1.0.0, CMSIS Driver:USB Host:Full-speed 1.3, CMSIS Driver:USB Host:High-speed 1.3, Compiler:I/O:STDIN 1.0.0, Compiler:I/O:STDOUT 1.0.0, Compiler:I/O:TTY 1.0.0, Device:STM32Cube Framework:STM32CubeMX 1.0.0, Device:STM32Cube HAL:Common 1.0.1, Device:STM32Cube HAL:Cortex 1.0.1, Device:STM32Cube HAL:DMA 1.0.1, Device:STM32Cube HAL:GPIO 1.0.1, Device:STM32Cube HAL:LTDC 1.0.1, Device:STM32Cube HAL:PWR 1.0.1, Device:STM32Cube HAL:RCC 1.0.1, Device:STM32Cube HAL:SDRAM 1.0.1, Device:Startup 1.0.1
